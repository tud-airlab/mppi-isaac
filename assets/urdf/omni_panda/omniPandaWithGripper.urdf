Commit message: adds config for omnipanda effort

File: assets/urdf/omni_panda/omniPandaWithGripper.urdf (robot description, URDF)
Before this commit: robot omniPanda, 16 links, 15 joints
Links:
- link base_link: mass 100.0 -> 20.0
